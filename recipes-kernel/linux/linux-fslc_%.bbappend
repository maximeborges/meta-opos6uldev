FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0100-ARM-dts-opos6ul-rework-device-tree-to-support-i.MX6U.patch"
SRC_URI += "file://0101-cpufreq-imx6q-check-speed-grades-for-i.MX6ULL.patch"
SRC_URI += "file://0102-ARM-dts-imx6ull-add-operating-points.patch"
SRC_URI += "file://0103-ARM-dts-opos6uldev-fix-pixel-clk-polarity.patch"
SRC_URI += "file://0104-ARM-dts-add-Armadeus-Systems-OPOS6ULNano-and-OPOS6UL.patch"
SRC_URI += "file://0106-ARM-dts-imx6ul-Add-CAAM-support.patch"
SRC_URI += "file://0107-ARM-dts-imx6ull-add-UART5-input-select-register-defi.patch"
SRC_URI += "file://0108-ARM-dts-imx6ull-add-UART5-RTS-input-select-register.patch"
SRC_URI += "file://0109-ARM-dts-imx6ull-keep-IMX6UL_-prefix-for-signals-on-b.patch"
SRC_URI += "file://0514-armadeus-remove-spidev-oops-warning-at-load-time.patch"
SRC_URI += "file://0800-armadeus-dts-opos6uldev-add-csi-pin-muxing.patch"
SRC_URI += "file://0800-armadeus-dts-opos6uldev-LQ043-LCD-support.patch"
SRC_URI += "file://0803-armadeus-brcmfmac-increase-boot-timeout.patch"
SRC_URI += "file://defconfig"
